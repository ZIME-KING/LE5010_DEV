# Keil uVision project sig_mesh_provee_auto_prov.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: sig_mesh_provee_auto_prov
  AfterMake: ..\..\..\..\..\..\tools\le501x\after_build.bat @L ..\..\..\..\..\.. dev\soc\arm_cm\le501x\bin\fw_with_sig_mesh.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 -O2
  c include: ..\..\..\..\..\module\crc;..\..\..\..\..\module\debug;..\..\..\..\..\module\debug\RTT;..\..\..\..\..\module\static_buffer;..\..\..\..\..\module\tinyfs;..\..\..\..\..\module\tinycrypt\lib\include;..\..\..\..\..\module\ble;..\..\..\..\..\module\ble\prf;..\..\..\..\..\module\ble\ll;..\..\..\..\..\module\common;..\..\..\..\..\module\adpcm;..\..\..\..\..\peripheral\ecc;..\..\..\..\..\peripheral\api;..\..\..\..\..\peripheral\inc;..\..\..\..\..\soc\arm_cm;..\..\..\..\..\soc\arm_cm\cmsis;..\..\..\..\..\soc\arm_cm\le501x;..\..\..\..\..\soc\arm_cm\le501x\integration;..\..\..\..\..\soc;..\..\..\..\..;..
  asm include: ..\..\..\..\..\module\crc;..\..\..\..\..\module\debug;..\..\..\..\..\module\debug\RTT;..\..\..\..\..\module\static_buffer;..\..\..\..\..\module\tinyfs;..\..\..\..\..\module\tinycrypt\lib\include;..\..\..\..\..\module\ble;..\..\..\..\..\module\ble\prf;..\..\..\..\..\module\ble\ll;..\..\..\..\..\module\common;..\..\..\..\..\module\adpcm;..\..\..\..\..\peripheral\ecc;..\..\..\..\..\peripheral\api;..\..\..\..\..\peripheral\inc;..\..\..\..\..\soc\arm_cm;..\..\..\..\..\soc\arm_cm\cmsis;..\..\..\..\..\soc\arm_cm\le501x;..\..\..\..\..\soc\arm_cm\le501x\integration;..\..\..\..\..\soc;..\..\..\..\..;..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\soc\arm_cm\le501x\compiler\armcc\link_script.txt
  link misc: --datacompressor=off --diag_suppress=L6314,L6329
  group app
    ../: main.c sig_mesh_ctl.c sig_mesh_vendor_event.c
  group module
    ../../../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../module/adpcm/: adpcm.c
    ../../../../../module/common/: circular_doubly_linked_list.c common.c linked_async_framework.c
    ../../../../../module/crc/: crc16.c
    ../../../../../module/tinycrypt/lib/source/: ecc.c ecc_dsa.c ecc_platform_specific.c sha256.c utils.c
    ../../../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../../../module/debug/: log.c ls_dbg.c
    ../../../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group peripheral
    ../../../../../peripheral/src/: adc_dma.c calc_div.c dmac.c lsadc.c lscache.c lscrypt.c lsi2c.c lsiwdg.c lspdm.c lspdm_dma.c lspis.c lsqspi.c lsrtc.c lsspi.c lsspi_dma.c lsssi.c lsssi_dma.c lstimer.c lstrng.c spi_flash.c uart.c uart_dma.c
    ../../../../../peripheral/ecc/: lsecc.c
  group soc
    ../../../../../soc/arm_cm/le501x/integration/: adc_msp.c calc_acc.c dmac_msp.c i2c_msp.c io_config.c lscache_msp.c lscrypt_msp.c lsiwdg_msp.c lspdm_msp.c lspis_msp.c lsqspi_msp.c lstimer_msp.c modem_rf_le501x.c rtc_msp.c spi_msp.c ssi_msp.c trng_msp.c uart_msp.c
    ../../../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sys_stat.c
    ../../../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S sleep_asm.S startup.S svcall_asm.S
    ../../../../../soc/: flash_svcall.c
    ../../../../../soc/arm_cm/le501x/bin/: libmesh.o
    ../../../../../soc/arm_cm/: svcall.c swint_handler.c systick.c
